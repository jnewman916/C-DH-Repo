# IAR project MSP-EXP430F5438_User_Experience.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xlfn.h
  General.OGChipSelectMenu: MSP430F5438A MSP430F5438A
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F5438.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: main.c UserExperience.c
  group MSP-EXP430F5438 HAL
    MSP-EXP430F5438 HAL/: cc2500.h hal_adc.c hal_adc.h hal_board.c hal_board.h hal_buttons.c hal_buttons.h hal_lcd.c hal_lcd.h hal_lcd_fonts.h hal_MSP-EXP430F5438.h hal_rf.c hal_rf.h hal_rf_settings.h hal_rtc.h hal_usb.c hal_usb.h RTCASMFunctions_IAR.s43
  group UserExperienceDemo
    UserExperienceDemo/: flashUtils.c flashUtils.h fsm.c fsm.h fsm_transition.c fsm_transition.h Puzzle.c Puzzle.h
